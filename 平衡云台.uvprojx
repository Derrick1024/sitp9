# Keil uVision project 平衡云台.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: 平衡云台 +hex
  c flags: Optim=2 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,
  c include: ..\sitp电控;.\delay;.\RTE;.\RTE\Device;.\RTE\Device\STM32F103RC;.\mpu6050_eMPL;.\TIM3_pwm;.\usart;.\mpu6050_eMPL\6050DMP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group main
    ./: main.c
  group usart
    ./usart/: bsp_usart1.c
  group delay
    ./delay/: systick_delay.c
  group PWM
    ./TIM3_pwm/: pwm_output.c
  group MPU6050_DMP
    ./mpu6050_eMPL/6050DMP/: anbt_dmp_driver.c anbt_dmp_mpu6050.c anbt_i2c.c
  group ::CMSIS
    d:/Keil_v5/ARM/PACK/ARM/CMSIS/4.1.1/CMSIS/Lib/ARM/: arm_cortexM3l_math.lib
  group ::Device
    RTE/Device/STM32F103RC/: RTE_Device.h startup_stm32f10x_hd.s stm32f10x_conf.h system_stm32f10x.c
    d:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.5/Device/StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    d:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.5/RTE_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c
software components: CMSIS:CORE 3.30.0, CMSIS:DSP 1.4.2, Device:DMA 1.01.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
